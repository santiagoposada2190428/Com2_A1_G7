options:
  parameters:
    generate_options: qt_gui
    id: LAB1
    output_language: python
    title: LAB1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '4'
    type: float
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[5]+[6]+[1]+[2]+[-1]+[-5]+[-2]+[-3]+[-3]'
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/vboxuser/Downloads/Cyberpunk-Edgerunners-OST-Full-I-Really-Want-to-Stay-At-Your-House-Sub-Español-EnglishAMV.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      class blk ( gr . sync_block ) :
          def __init__ ( self ) : # only default a r g u m e n t s here
              gr . sync_block . __init__ (
                  self ,
                  name = "e_Diff" ,
                  # will show up in GRC
                  in_sig =[ np . float32 ] ,
                  out_sig =[ np . float32 ]
              
              )
              self . acum_anterior = 0
          def work ( self , input_items , output_items ) :
              x = input_items [0]# Senial de entrada .
              y0 = output_items [0] # Senial a c u m u l a d a d i f e r e n c i a l
              N = len ( x )
              for i in range(N):
                  y0 [i] = x[i]  - self.acum_anterior
                  self.acum_anterior = x [i]


              
              return len ( y0 )
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      class blk (gr. sync_block ):
          def __init__ ( self ) : # only default arguments here
              gr. sync_block . __init__ (
                  self ,
                  name ="e_Acum" , # will show up in GRC
                  in_sig =[ np. float32 ],
                  out_sig =[ np. float32 ]
              )
              self.acum_anterior=0
          def work (self , input_items , output_items ):
              x = input_items [0] # Senial de entrada .
              y0 = output_items [0] # Senial acumulada
              y0 [:] = self.acum_anterior+np. cumsum (x)
              self.acum_anterior=y0 [-1]
              return len (y0)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nclass blk ( gr . sync_block ) :\n    def __init__ ( self ) : # only default a r g u m e n t s here\n        gr . sync_block . __init__ (\n            self ,\n            name = \"Promedio de tiempos\",# will show up in GRC\n            in_sig =[ np . float32 ] ,\n            out_sig =[ np . float32 , np . float32 , np . float32 , np . float32 , np . float32 ]\n        )\n        self.acum_anterior = 0\n        self.Ntotales = 0\n        self.acum_anterior1 = 0\n        self.acum_anterior2 = 0\n    def work ( self , input_items , output_items ) :\n        x = input_items [0]\n        # Senial de entrada .\n        y0 = output_items [0] # P r o m e d i o de la senial\n        y1 = output_items [1] # Media de la senial\n        y2 = output_items [2] # RMS de la senial\n        y3 = output_items [3] # P o t e n c i a p r o m e d i o de la senial\n        y4 = output_items [4] # D e s v i a c i o n e s t a n d a r de la senial\n\n        # Calculo del p r o m e d i o\n\n        N = len ( x )\n        self.Ntotales = self.Ntotales + N\n        acumulado = self.acum_anterior + np.cumsum ( x )\n        self.acum_anterior = acumulado [N -1]\n        y0 [:]= acumulado/self.Ntotales\n\n        # Calculo de la media c u a d r a t i c a\n\n        x2 = np.multiply (x , x )\n        acumulado1 = self.acum_anterior1 + np.cumsum ( x2 )\n        self.acum_anterior1 = acumulado [N -1]\n        y1 [:] = acumulado1/self.Ntotales\n\n        # Calculo de la RMS\n\n        y2 [:] = np.sqrt ( y1 )\n\n        # Calculo de la p o t e n c i a p r o m e d i o\n\n        y3 [:] = np.multiply ( y2 , y2 )\n\n        # Calculo de la d e s v i a c i o n e s t a n d a r\n\n        x3 = np.multiply (x - y0 ,x - y0 )\n        acumulado2 = self.acum_anterior2 + np.cumsum ( x3 )\n        self.acum_anterior2 = acumulado2 [N -1]\n        y4 [:] = np.sqrt ( acumulado2/self.Ntotales )\n\n        return len ( x )\n\n"
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Promedio"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Media cuadratica"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '2'
    min: '-2'
    name: '"RMS"'
    type: float
  states: {}
- name: qtgui_number_sink_0_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Potencia promedio"'
    type: float
  states: {}
- name: qtgui_number_sink_0_3
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Desviacion estandar"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Salida Acumulador
    label2: Entrada
    marker1: '0'
    marker2: '2'
    name: '"salida"'
    nconnections: '2'
    size: '20'
    srate: samp_rate
    type: float
    width1: '4'
    ymax: '30'
    ymin: '-30'
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Salida Diferenciador
    label2: Entrada
    marker1: '0'
    marker2: '2'
    name: '"salida"'
    nconnections: '2'
    size: '20'
    srate: samp_rate
    type: float
    width1: '4'
    ymax: '30'
    ymin: '-30'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', epy_block_0, '0']
- [blocks_add_xx_0, '0', epy_block_0_0, '0']
- [blocks_add_xx_0, '0', epy_block_1, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_1_0, '1']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_1_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_0, '0', epy_block_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', epy_block_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_1_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_1_0_0, '1']
- [blocks_vector_source_x_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_vector_source_x_0_0_0, '0', epy_block_0, '0']
- [blocks_vector_source_x_0_0_0, '0', epy_block_0_0, '0']
- [blocks_vector_source_x_0_0_0, '0', epy_block_1, '0']
- [blocks_vector_source_x_0_0_0, '0', qtgui_time_sink_x_0_1_0, '1']
- [blocks_vector_source_x_0_0_0, '0', qtgui_time_sink_x_0_1_0_0, '1']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0_1_0_0, '0']
- [epy_block_0_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [epy_block_1, '0', qtgui_number_sink_0, '0']
- [epy_block_1, '1', qtgui_number_sink_0_0, '0']
- [epy_block_1, '2', qtgui_number_sink_0_1, '0']
- [epy_block_1, '3', qtgui_number_sink_0_2, '0']
- [epy_block_1, '4', qtgui_number_sink_0_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
